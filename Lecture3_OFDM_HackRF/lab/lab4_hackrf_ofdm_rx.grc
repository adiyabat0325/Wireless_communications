options:
  parameters:
    author: NUM Wireless Communication Lab
    description: HackRF Pro -> GNU Radio OFDM Receiver -> decoded text packets.
    generate_options: qt_gui
    id: lab4_hackrf_ofdm_rx
    output_language: python
    title: 'Lab 4c - OFDM packet receiver (HackRF Pro #2)'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
    comment: Use only a frequency allowed in your lab / country
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '64'
    comment: bytes per packet
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
    comment: 48 data subcarriers (DC = 0 is not used)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1),)
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    label: '"RX LNA gain [dB]"'
    rangeType: int
    value: '16'
    start: '0'
    stop: '40'
    step: '8'
    gui_hint: 0,0,1,1
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: '"RX VGA gain [dB]"'
    rangeType: int
    value: '20'
    start: '0'
    stop: '62'
    step: '2'
    gui_hint: 0,1,1,1
  states: {}
- name: hackrf_rx
  id: soapy_hackrf_source
  parameters:
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    center_freq: center_freq
    gain: lna_gain
    vga: vga_gain
    comment: 'dev_args: leave empty for one HackRF; with two HackRFs on one PC use serial=<number from hackrf_info>'
  states: {}
- name: ofdm_rx
  id: digital_ofdm_rx
  parameters:
    fft_len: fft_len
    cp_len: cp_len
    packet_len_key: '"rx_len"'
    occupied_carriers: occupied_carriers
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: None
    sync_word2: None
    header_mod: '"BPSK"'
    payload_mod: '"QPSK"'
    comment: Must use the SAME parameters as the transmitter
  states: {}
- name: print_packets
  id: blocks_file_sink
  parameters:
    file: '"/dev/stdout"'
    type: byte
    unbuffered: 'True'
    comment: Decoded packets are printed in the GRC console
  states: {}
- name: save_packets
  id: blocks_file_sink
  parameters:
    file: '"rx_packets.txt"'
    type: byte
    unbuffered: 'True'
    comment: 'Packet error rate: python3 lab4_per.py rx_packets.txt'
  states: {}
- name: spec
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"RX spectrum"'
    fftsize: '1024'
    fc: center_freq
    bw: samp_rate
    average: '0.2'
    ymin: '-110'
    ymax: '-10'
    grid: 'True'
    gui_hint: 1,0,1,1
  states: {}
- name: wfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"RX waterfall"'
    fftsize: '1024'
    fc: center_freq
    bw: samp_rate
    int_min: '-110'
    int_max: '-30'
    gui_hint: 1,1,1,1
  states: {}
- name: tscope
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"RX samples (check: no clipping, |x| < 0.7)"'
    size: '8192'
    srate: samp_rate
    grid: 'True'
    entags: 'False'
    gui_hint: 2,0,1,2
  states: {}

connections:
- [hackrf_rx, '0', ofdm_rx, '0']
- [ofdm_rx, '0', print_packets, '0']
- [ofdm_rx, '0', save_packets, '0']
- [hackrf_rx, '0', spec, '0']
- [hackrf_rx, '0', wfall, '0']
- [hackrf_rx, '0', tscope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
